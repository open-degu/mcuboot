## boot/zephyr/boards/degu_evk.conf
```kconfig
CONFIG_BOOT_USB_DFU_MODE=y
CONFIG_USB_COMPOSITE_DEVICE=y
CONFIG_BOOT_UPGRADE_ONLY=y

# Disable unnecessary peripherals
CONFIG_I2C=n
CONFIG_ADC=n
```
